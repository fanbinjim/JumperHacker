## fanbin/Kconfig
```kconfig
config FANBIN
    tristate "fanbin driver for pwm servo"
    help
        Driver for pwm servo
```
